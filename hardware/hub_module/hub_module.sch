File: hardware/hub_module/hub_module.sch (KiCad schematic (older format))
At the start: 0 parts

Commit message: busses added
